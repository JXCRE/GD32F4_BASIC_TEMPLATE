# Keil uVision project GD32F4.uvprojx, settings and files
target GD32F4 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F427VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.5.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F4 +hex
  AfterMake: fromelf --bin --output=..\5_Burn\gd32f4.bin ..\3_Output\GD32F4.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F427
  c include: ..\2_Source\Board\CMSIS;..\2_Source\Board\Library\Include;..\2_Source\Bsp;..\2_Source\Common;..\2_Source\User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../2_Source/User/: main.c
  group Bsp
    ../2_Source/Bsp/: board.c bsp.c gd32f4xx_it.c adc.c dac.c dma.c exit.c fmc.c gpio.c i2c.c spi.c timer.c uart.c
  group Common
    ../2_Source/Common/: fifo.c queue.c
  group Library
    ../2_Source/Board/Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../2_Source/Board/CMSIS/: system_gd32f4xx.c
  group Startup
    ../2_Source/Board/Startup/: startup_gd32f407_427.s
